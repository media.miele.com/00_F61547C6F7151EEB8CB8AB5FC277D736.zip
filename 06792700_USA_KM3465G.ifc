Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2020-11-25T10:39:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Nov 25 10:39:12 2020 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{2B62B70D-C7E1-4279-B167-AAAF730B5604}\ifc * Database version: 5507 * Database creation date: Wed Nov 25 10:39:11 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Nov 25 10:39:11 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Nov 25 10:39:11 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 26346550_USA_6792700_KM3465G, 06792700_USA_KM3465G:26346550_USA_6792700_KM3465G:211994
In: Level 1
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Cast, z_Miele_Design_CLST, z_Miele_Connection_Gas, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - Reference: 26346550_USA_6792700_KM3465G
Pset_ManufacturerTypeInformation - Manufacturer: Miele
